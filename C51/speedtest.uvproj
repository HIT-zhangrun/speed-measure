# Keil uVision project speedtest.uvproj, settings and files
target speedtest (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: speedtest +hex
  c flags: Optimize=8 SizeSpeed=1
  group speedtest
    ./: STARTUP.A51 main.c delay.c lcd128128.c speed.c
